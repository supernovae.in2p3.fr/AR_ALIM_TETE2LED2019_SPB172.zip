# Allegro board autosave.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UNNAMED_1_POT_I53_A: length 27.2
  BOTTOM w0.6: S28.1 53.79,111.53 PO28.1
UNNAMED_1_POT_I53_B: length 48.3
  BOTTOM w0.8: PO28.2 78.61,110.26 123.34,110.26 R28.2
UNNAMED_1_POT_I54_A: length 39.9
  BOTTOM w0.6: S26.1 53.79,116.61 PO26.1
UNNAMED_1_POT_I54_B: length 35.6
  BOTTOM w0.8: PO26.2 91.31,115.34 123.34,115.34 R26.2
UNNAMED_1_POT_I55_A: length 46.3
  BOTTOM w0.6: PO25.1 53.79,119.15 S25.1
UNNAMED_1_POT_I55_B: length 41
  BOTTOM w0.8: PO25.2 97.66,117.88 133.54,117.88 134.8,116.61 R25.2
UNNAMED_1_POT_I56_A: length 52.6
  BOTTOM w0.6: S24.1 53.79,121.69 PO24.1
UNNAMED_1_POT_I56_B: length 22.9
  BOTTOM w0.8: R24.2 123.34,120.42 104.01,120.42 PO24.2
UNNAMED_1_POT_I57_A: length 65.3
  BOTTOM w0.6: PO22.1 53.79,126.77 S22.1
UNNAMED_1_POT_I57_B: length 9.2
  BOTTOM w0.8: R22.2 PO22.2
UNNAMED_1_POT_I58_A: length 73.8
  BOTTOM w0.6: S21.1 55.03,130.55 112.38,130.55 112.42,130.51 115.61,130.51 PO21.1
UNNAMED_1_POT_I58_B: length 16.5
  BOTTOM w0.8: R21.2 126.75,126.77 PO21.2
UNNAMED_1_POT_I59_A: length 59
  BOTTOM w0.6: S23.1 53.79,124.23 PO23.1
UNNAMED_1_POT_I59_B: length 28.3
  BOTTOM w0.8: R23.2 134.8,121.69 133.54,122.96 110.36,122.96 PO23.2
UNNAMED_1_POT_I72_A: length 48
  BOTTOM w0.6: PO37.1 89.87,79.79 53.88,79.79 S37.1
UNNAMED_1_POT_I72_B: length 41.9
  BOTTOM w0.8: R37.2 101.29,86.13 PO37.2
UNNAMED_1_POT_I73_A: length 41.4
  BOTTOM w0.6: S36.1 53.68,82.53 83.72,82.53 PO36.1
UNNAMED_1_POT_I73_B: length 36.6
  BOTTOM w0.8: R36.2 94.94,88.67 PO36.2
UNNAMED_1_POT_I74_A: length 35
  BOTTOM w0.6: S35.1 53.61,85.15 77.45,85.15 PO35.1
UNNAMED_1_POT_I74_B: length 54.6
  BOTTOM w0.8: PO35.2 88.59,91.21 R35.2
UNNAMED_1_POT_I75_A: length 28.8
  BOTTOM w0.6: PO34.1 70.94,87.53 53.77,87.53 S34.1
UNNAMED_1_POT_I75_B: length 49.3
  BOTTOM w0.8: PO34.2 82.24,93.75 R34.2
UNNAMED_1_POT_I84_A: length 73.7
  BOTTOM w0.6: PO60.1 112.9,15.56 108.97,11.63 63.62,11.63 S60.1
UNNAMED_1_POT_I84_B: length 11
  BOTTOM w0.8: R60.2 119.86,20.09 PO60.2
UNNAMED_1_POT_I85_A: length 64.5
  BOTTOM w0.6: S59.1 63.32,14.47 102.81,14.47 PO59.1
UNNAMED_1_POT_I85_B: length 32.4
  BOTTOM w0.8: R59.2 112.11,22.63 109.09,19.61 PO59.2
UNNAMED_1_POT_I86_A: length 58.1
  BOTTOM w0.6: S58.1 63.29,17.05 96.5,17.05 PO58.1
UNNAMED_1_POT_I86_B: length 24.7
  BOTTOM w0.8: PO58.2 109.7,25.17 R58.2
UNNAMED_1_POT_I87_A: length 25.2
  BOTTOM w0.6: PO53.1 66.48,31.48 64.83,31.48 62.91,33.4 59.06,33.4 50.26,42.2 50.26,42.78 S53.1
UNNAMED_1_POT_I87_B: length 68.2
  BOTTOM w0.8: PO53.2 77.95,37.87 R53.2
UNNAMED_1_POT_I88_A: length 17
  BOTTOM w0.6: PO52.1 59.58,35.99 56.92,38.66 56.92,38.83 50.44,45.32 50.26,45.32 S52.1
UNNAMED_1_POT_I88_B: length 62.8
  BOTTOM w0.8: PO52.2 71.6,40.41 R52.2
UNNAMED_1_POT_I89_A: length 8.5
  BOTTOM w0.6: PO51.1 54.93,44.26 53.86,44.26 S51.1
UNNAMED_1_POT_I89_B: length 79.3
  BOTTOM w0.8: R51.2 134.8,42.95 133.91,42.06 63.79,42.06 63.25,42.59 59.99,42.59 PO51.2
UNNAMED_1_POT_I90_A: length 14.9
  BOTTOM w0.6: PO50.1 54.68,45.97 S50.1
UNNAMED_1_POT_I90_B: length 61.6
  BOTTOM w0.8: R50.2 123.43,44.32 70.23,44.32 69.31,45.24 66.45,45.24 PO50.2
UNNAMED_1_POT_I91_A: length 21.2
  BOTTOM w0.6: S49.1 54.68,48.51 PO49.1
UNNAMED_1_POT_I91_B: length 67.1
  BOTTOM w0.8: R49.2 134.8,48.03 133.64,46.87 76.33,46.87 75.17,48.03 73.05,48.03 PO49.2
UNNAMED_1_POT_I92_A: length 33.9
  BOTTOM w0.6: PO47.1 54.68,53.59 S47.1
UNNAMED_1_POT_I92_B: length 54.5
  BOTTOM w0.8: R47.2 134.8,53.11 133.54,51.85 89.16,51.85 87.9,53.11 85.75,53.11 PO47.2
UNNAMED_1_POT_I93_A: length 27.6
  BOTTOM w0.6: PO48.1 54.68,51.05 S48.1
UNNAMED_1_POT_I93_B: length 48.9
  BOTTOM w0.8: PO48.2 79.4,50.57 81.38,50.57 82.28,49.68 123.71,49.68 R48.2
UNNAMED_1_POT_I94_A: length 40.3
  BOTTOM w0.6: S46.1 54.68,56.13 PO46.1
UNNAMED_1_POT_I94_B: length 36.7
  BOTTOM w0.8: PO46.2 91.66,55.21 94.96,55.21 96.47,53.7 122.65,53.7 R46.2
UNNAMED_1_POT_I95_A: length 46.6
  BOTTOM w0.6: PO45.1 54.68,58.67 S45.1
UNNAMED_1_POT_I95_B: length 40.8
  BOTTOM w0.8: R45.2 134.8,58.19 133.9,57.29 97.55,57.29 PO45.2
UNNAMED_1_POT_I96_A: length 53
  BOTTOM w0.6: S44.1 54.8,61.09 PO44.1
UNNAMED_1_POT_I96_B: length 22.8
  BOTTOM w0.8: R44.2 123.7,59.83 104.02,59.83 PO44.2
UNNAMED_1_POT_I97_A: length 65.7
  BOTTOM w0.6: PO42.1 54.8,66.17 S42.1
UNNAMED_1_POT_I97_B: length 10.1
  BOTTOM w0.8: R42.2 123.51,64.72 116.53,64.72 PO42.2
UNNAMED_1_POT_I98_A: length 72.2
  BOTTOM w0.6: S41.1 54.98,68.53 PO41.1
UNNAMED_1_POT_I98_B: length 15.4
  BOTTOM w0.8: R41.2 124.21,68.35 PO41.2
UNNAMED_1_POT_I99_A: length 59.4
  BOTTOM w0.6: S43.1 54.8,63.63 PO43.1
UNNAMED_1_POT_I99_B: length 29.2
  BOTTOM w0.8: R43.2 121.96,63.27 120.46,61.77 114.79,61.77 113.44,63.12 111.12,63.12 PO43.2
UNNAMED_1_POT_I112_A: length 51.9
  BOTTOM w0.6: S57.1 63.45,19.42 89.98,19.42 PO57.1
UNNAMED_1_POT_I112_B: length 42.8
  BOTTOM w0.8: PO57.2 103.35,27.71 R57.2
UNNAMED_1_POT_I113_A: length 45.6
  BOTTOM w0.6: S56.1 63.54,21.87 83.54,21.87 PO56.1
UNNAMED_1_POT_I113_B: length 37.4
  BOTTOM w0.8: PO56.2 97,30.25 R56.2
UNNAMED_1_POT_I114_A: length 39.2
  BOTTOM w0.6: S55.1 63.49,24.46 77.24,24.46 PO55.1
UNNAMED_1_POT_I114_B: length 55.5
  BOTTOM w0.8: R55.2 90.65,32.79 PO55.2
UNNAMED_1_POT_I115_A: length 32.9
  BOTTOM w0.6: S54.1 63.57,26.92 70.81,26.92 PO54.1
UNNAMED_1_POT_I115_B: length 50.1
  BOTTOM w0.8: R54.2 84.3,35.33 PO54.2
UNNAMED_1_STRAP_I125_B: length 149.9
  BOTTOM w1.4: S1.2 S2.2 S3.2 S4.2 S5.2 S6.2 S7.2 S8.2 S9.2 S10.2 S11.2 S12.2 S13.2 S14.2 S15.2 S16.2 S17.2 S18.2 S19.2 S20.2 S21.2 S22.2 S23.2 S24.2 S25.2 S26.2 S27.2 S28.2 S29.2 S30.2 S31.2 S32.2 S33.2 S34.2 S35.2 S36.2 S37.2 S38.2 S39.2 S40.2 S41.2 S42.2 S43.2 S44.2 S45.2 S46.2 S47.2 S48.2 S49.2 S50.2 S51.2 S52.2 S53.2 S54.2 S55.2 S56.2 S57.2 S58.2 S59.2 S60.2

## Copper pours and planes (outline as drawn)
GND on TOP: 7.46,7.64 7.46,196.64 174.46,196.64 174.46,7.64 122.12,7.64 122.12,10.4 118.06,10.4 118.06,7.64
GND on BOTTOM: 7.46,7.64 7.46,196.64 174.46,196.64 174.46,7.64 122.12,7.64 122.12,10.4 118.06,10.4 118.06,7.64 ; 12 cut-outs

## Text on the board
BOTTOM: 2
TOP: 1
DIMENSION: ALIM_TETE2LED2019_COTE_ELEMENTS
DISPLAY_BOTTOM: ALIM_TETE2LED2019_COTE_SOUDURES
COMPVAL_TYPE_TOP: ALIM_TETE2LED2019_PLAN_CABLAGE_ELEMENTS
COMPVAL_TYPE_BOTTOM: ALIM_TETE2LED2019_PLAN_CABLAGE_SOUDURES
User.6: 598-8140-107F | 598-8150-107F | 598-8120-107F | UVLED365_SMD | LA_W5SM_JYKY | LY_W5SM_HZJZ | APG2C1_375 | APG2C1_740 | SM1204UOC | SM1204UYC | PSML31.13 | SM1204SGC | GW_JCLMS1 | LTQ39G-Q1 | 598-8181 | RLCU-375 | RLCU-365 | RLCU-355 | RLCU-410 | RLCU-400 | 598-8130 | RLCU-380 | LT_W5SM | LD_W5AM | SMT850N | SMC1050 | LB_W5SM | SMC660N | SMC780 | SMC630 | SMC890 | SMCXXX | SMC720 | SMC680 | SMC430 | SMT570 | SMT700 | SMC830 | SMC970 | SMC870 | SMC810 | SMC940 | SMC735 | SMC770 | SMC750 | SMC395 | SMC415 | SMC565 | SMC405 | SMC525 | SMC910 | 598-8191-107F | LV_W5AM_JZKZ_25 | RLCU | SMC490 | 598-8181-107F | SMC470 | 598-8110-107F | LD-W5AM-1U4U-35 | PSLM31.13-GUHQ-26-MP | LB-W5SM-FZH-35 | 598-8130-107F | LTQ39G-Q152-25-1 | LA-W5SM-JYKY-24 | APG2C1-375 | APG2C1-740 | LT-W5SM-JYKI-25 | GW-JCLMS1 | PSLM31.13 | 598-8150 | 598-8140 | LD-W5AM | LT-W5SM | AP2GC1 | 598-8120 | 598-8110 | LA_W5SM | 598-8191 | LY_W5SM | LB-W5SM | LV_W5AM | LTQ39G | LY-W5SM-HZJZ-46 | VCC | GND | ALIM_TETE2LED2019 | 06/2019      DICE | ALIM_TETE2LED2019_SERIGRAPHIE_ELEMENTS
User.7: RLCU-410 | PSLM31.13-GUHQ-26-MP | LA_W5SM_JYKY_24 | UVLED365_SMD | GW-JCLMS1 | SMC415 | SM1204UOC | RLCU-355 | RLCU-365 | RLCU-375 | SM1204SGC | SMC890 | RLCU-380 | LD_W5AM_1U4U_35 | 598-8150-107F | APG2C1_375 | SMC395 | RLCU-400 | LB_W5SM_FZH_35 | RLCU | SMC565 | 598-8120-107F | SMC830 | SMC910 | SMC1050 | SMC470 | LT_W5SM_JYKI_25 | 598-8130-107F | LTQ39G-Q152-25-1 | SMC405 | 598-8191-107F | SMC490 | SM1204UYC | SMC940 | SMT570 | SMC870 | SMC525 | 598-8140-107F | LY_W5SM_HZJZ_46 | SMC430 | 598-8181-107F | LV_W5AM_JZKZ_25 | SMT850N | SMC970 | SMCXXX | SMC770 | SMC630 | SMC810 | SMC680 | SMT700 | SMC720 | SMC735 | SMC750 | SMC780 | SMC660N | APG2C1_740 | 598-8110-107F | LD-W5AM-1U4U-35 | LB-W5SM-FZH-35 | APG2C1-375 | APG2C1-740 | LA-W5SM-JYKY-24 | LT-W5SM-JYKY-25 | AP2GC1 | LD-W5AM | LT-W5SM | 598-8181 | 598-8150 | 598-8140 | 598-8130 | PSLM31.13 | AP2GC1-375 | LTQ39G | LY_W5SM | LA_W5SM | LB-W5SM | LV_W5AM | 598-8120 | 598-8191 | 598-8110 | VCC | GND | ALIM_TETE2LED2019 | 06/2019      DICE | ALIM_TETE2LED2019_SERIGRAPHIE_SOUDURES
User.8: ALIM_TETE2LED2019_VERNIS_EPARGNE_ELEMENTS
User.9: ALIM_TETE2LED2019_VERNIS_EPARGNE_SOUDURES
User.12: ALIM_TETE2LED2019_DIMENSIONS
User.13: ALIM_TETE2LED2019_PLAN_PERCAGE
User.26: FIGURE | FINISHED_SIZE | 0.3 | 0.8 | 0.9 | 1.0 | 1.35 | 1.4 | 3.2 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILLIMETERS | PLATED | QTY | 481 | 300 | 60 | 246 | 3 | 6 | 8
